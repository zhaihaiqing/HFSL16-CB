# Keil uVision project Project.uvprojx, settings and files
target STM32L1XX_MD(STM32L1xxxBxx) (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152-EVAL +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\;..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;C:\Keil_v5\ARM\Pack\Keil\STM32L1xx_DFP\1.0.2\Device\Include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group User
    ../: main.c stm32l1xx_it.c gpio.c SPI.c time.c I2C.c uart.c pwm.c InputCapture.c ds18b20.c
  group StdPeriph_Driver
    ../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ../: system_stm32l1xx.c
  group MDK-ARM
    ../../Libraries/MDK-ARM/: startup_stm32l1xx_md.s
